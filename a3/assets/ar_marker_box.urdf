Commit message: a3_u1

File: a3/assets/ar_marker_box.urdf (robot description, URDF)
Before this commit: robot ar_marker_box, 1 links, 0 joints
Links:
- link box: geometry collision box size=0.14 0.14 0.14; visual mesh filename=/visual/ar_marker_box.obj scale=0.5 0.5 0.5
